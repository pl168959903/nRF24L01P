# Keil uVision project nRF24L01_lib.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: M032SG8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.11
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: nRF24L01_lib (library)
  c flags: Optim=7 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: nRF24L01_Base.c nRF24L01_Drv.c
